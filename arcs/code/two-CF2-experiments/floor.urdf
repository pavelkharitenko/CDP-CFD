Commit message: added dw forces collecting scenario

File: arcs/code/two-CF2-experiments/floor.urdf (robot description, URDF)
Before this commit: robot floor, 2 links, 1 joints
Links:
- link main: geometry collision box size=.2 .2 0.001; visual mesh filename=meshes/floor.stl scale=0.2 0.2 0.2
